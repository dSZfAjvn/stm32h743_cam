# Keil uVision project CU.uvprojx, settings and files
target CU (ARM-ADS)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: CU +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Inc;      ../Drivers/STM32H7xx_HAL_Driver/Inc;      ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;      ../Middlewares/Third_Party/FatFs/src;      ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;      ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User
    ../Src/: bmp.c main.c gpio.c dcmi.c dma.c bsp_driver_sd.c sd_diskio.c fatfs.c fatfs_platform.c i2c.c sdmmc.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
software components: CMSIS:CORE 4.3.0
